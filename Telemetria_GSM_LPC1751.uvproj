# Keil uVision project Telemetria_GSM_LPC1751.uvproj, settings and files
target TelemetriaGSM_LPC1751 (ARM-ADS)
  device: LPC1751 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Telemetria_GSM_LPC1751
  c flags: Optim=2
  c include: C:\Keil\ARM\INC\NXP\LPC17xx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Sources
    ./: main.c gpio.c uart.c wdt.c timer.c sim900.c application.c rs485.c comandos_dados_sensor.c lcd.c
  group Headers
    ./: gpio.h timer.h uart.h wdt.h type.h sim900.h application.h rs485.h telemetria.h comandos_dados_sensor.h lcd.h
